# Keil uVision project 1_Heart_register.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 01_LED_Register +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Start;.\driver\Usart;.\common\Debug;.\app\communication;.\driver\TIMER;.\driver\USART;.\app\heart_collect;.\driver\ADC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group main
    ./: main.c
  group Common
    ./common/Debug/: Common_Debug.c
  group Driver
    ./driver/Usart/: Driver_Usart1.c
    ./driver/ADC/: Driver_ADC1.c
    ./driver/TIMER/: Driver_TIM7.c
  group Start
    ./Start/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group APP
    ./app/communication/: App_communication.c
    ./app/heart_collect/: App_Heart_Collect.c
